# Keil uVision project uso_arm_usb_bo.uvproj, settings and files
target MEDIA_USB_KEY (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: uso_arm_usb_bo +hex
  c flags: OneElfS=1
  c define: USE_STDPERIPH_DRIVER, USE_USB_OTG_FS, STM32F4XX, MEDIA_USB_KEY, __FPU_PRESENT=0
  c include: .\Libraries;.\Utilities;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\inc;.\src;.\Libraries\STM32F4xx_StdPeriph_Driver;.\Libraries\STM32_USB_HOST_Library;.\Libraries\STM32_USB_OTG_Driver;.\Utilities\STM32F4-Discovery;.\Libraries\CMSIS;.\Utilities\Third_Party\fat_fs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./src/: gpio.c rtc.c gpio.h rtc.h main.c system_stm32f4xx.c usb_bsp.c usbh_usr.c stm32f4xx_it.c
    ./: readme.txt
  group STM32F4-Discovery
    ./Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ./Libraries/CMSIS/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_flash.c
  group MDK-ARM
    ./src/: startup_stm32f4xx.s
  group STM32_USB_OTG_Driver
    ./Libraries/STM32_USB_OTG_Driver/: usb_core.c usb_hcd.c usb_hcd_int.c
  group STM32_USB_HOST_Library
    ./Libraries/STM32_USB_HOST_Library/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_stdreq.c usbh_msc_scsi.c
  group FAT_FS
    ./Utilities/Third_Party/fat_fs/: fattime.c ff.c
target deb (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: uso_arm_usb_bo +hex
  c flags: Optim=4 OneElfS=1
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x4000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x400000
  memory RVCT10: RAM 0x10000000 size 0x10000
